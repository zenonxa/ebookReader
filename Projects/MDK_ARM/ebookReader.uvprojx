# Keil uVision project ebookReader.uvprojx, settings and files
target ebookReader (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ebookReader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\;..\..\Middlewares;..\..\User;..\..\Middlewares\LVGL\GUI;..\..\Middlewares\LVGL\GUI\lvgl;..\..\Middlewares\LVGL\GUI\lvgl\src;..\..\Middlewares\LVGL\GUI\lvgl\examples\porting
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_ll_fsmc.c
  group SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/ATK_MD0700/: atk_md0700_fsmc.c atk_md0700_touch_iic.c atk_md0700_touch.c atk_md0700.c
    ../../Drivers/BSP/TIMER/: timer.c
    ../../Drivers/BSP/SRAM/: sram.c
  group Middlewares/lvgl/examples/porting
    ../../Middlewares/LVGL/GUI/lvgl/examples/porting/: lv_port_disp.c lv_port_indev.c
  group Middlewares/lvgl/src/core
    ../../Middlewares/LVGL/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group Middlewares/lvgl/src/draw
    ../../Middlewares/LVGL/GUI/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../../Middlewares/LVGL/GUI/lvgl/src/draw/gd32_ipa/: lv_gpu_gd32_ipa.c
    ../../Middlewares/LVGL/GUI/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../../Middlewares/LVGL/GUI/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../../Middlewares/LVGL/GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../../Middlewares/LVGL/GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../../Middlewares/LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../../Middlewares/LVGL/GUI/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../../Middlewares/LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_cache_builtin.c lv_img_decoder.c
  group Middlewares/lvgl/src/font
    ../../Middlewares/LVGL/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group Middlewares/lvgl/src/hal
    ../../Middlewares/LVGL/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group Middlewares/lvgl/src/layouts
    ../../Middlewares/LVGL/GUI/lvgl/src/layouts/flex/: lv_flex.c
    ../../Middlewares/LVGL/GUI/lvgl/src/layouts/grid/: lv_grid.c
  group Middlewares/lvgl/src/misc
    ../../Middlewares/LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_malloc_builtin.c lv_math.c lv_mem.c lv_memcpy_builtin.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group Middlewares/lvgl/src/others
    ../../Middlewares/LVGL/GUI/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../../Middlewares/LVGL/GUI/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../Middlewares/LVGL/GUI/lvgl/src/others/gridnav/: lv_gridnav.c
    ../../Middlewares/LVGL/GUI/lvgl/src/others/ime/: lv_ime_pinyin.c
    ../../Middlewares/LVGL/GUI/lvgl/src/others/imgfont/: lv_imgfont.c
    ../../Middlewares/LVGL/GUI/lvgl/src/others/monkey/: lv_monkey.c
    ../../Middlewares/LVGL/GUI/lvgl/src/others/msg/: lv_msg.c
    ../../Middlewares/LVGL/GUI/lvgl/src/others/snapshot/: lv_snapshot.c
  group Middlewares/lvgl/src/themes
    ../../Middlewares/LVGL/GUI/lvgl/src/themes/basic/: lv_theme_basic.c
    ../../Middlewares/LVGL/GUI/lvgl/src/themes/default/: lv_theme_default.c
    ../../Middlewares/LVGL/GUI/lvgl/src/themes/mono/: lv_theme_mono.c
  group Middlewares/lvgl/src/widgets
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/animimg/: lv_animimg.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/arc/: lv_arc.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/bar/: lv_bar.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/btn/: lv_btn.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/btnmatrix/: lv_btnmatrix.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/canvas/: lv_canvas.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/chart/: lv_chart.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/colorwheel/: lv_colorwheel.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/img/: lv_img.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/imgbtn/: lv_imgbtn.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/label/: lv_label.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/led/: lv_led.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/line/: lv_line.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/list/: lv_list.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/menu/: lv_menu.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/meter/: lv_meter.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/roller/: lv_roller.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/slider/: lv_slider.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/span/: lv_span.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/spinner/: lv_spinner.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/switch/: lv_switch.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/table/: lv_table.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/tabview/: lv_tabview.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/textarea/: lv_textarea.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/tileview/: lv_tileview.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/win/: lv_win.c
  group User
    ../../User/: main.c stm32f1xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Test
    ../../User/Test/: test_atk_md0700.c
